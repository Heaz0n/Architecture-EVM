# Keil uVision project f0ledblink.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f0ledblink +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\source;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\CMSIS\Device\ST\STM32F0xx;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\STM32F0xx_StdPeriph_Driver\src;.\Libraries\CMSIS\Include;.\source\nrf24l01
  asm include: .\source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./source/: startup_stm32f0xx.s system.c GPB.s main.c
